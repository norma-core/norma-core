PACKAGECONFIG:append = " at"
PACKAGECONFIG:remove = "systemd polkit"
